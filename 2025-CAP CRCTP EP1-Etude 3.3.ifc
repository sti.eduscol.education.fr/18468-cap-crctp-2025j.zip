Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Any]
File name: EP1- question3 .ifc
Time: 2024-11-27T11:02:44
Author: Frederic
Organization: Trimble
Written by: TrimBimToIFC ver 1.0
Made in: TrimBimToIFC ver 1.0
Authorization: IFC4 model

# IfcSite (2)
Name

Renouvellement du réseau de distribution d'eau potable - Rue Henri Meck SAVERNE - | IfcSite - CompositionType: ELEMENT; RefElevation: 10; RefLatitude: 24.28; RefLongitude: 54.25
