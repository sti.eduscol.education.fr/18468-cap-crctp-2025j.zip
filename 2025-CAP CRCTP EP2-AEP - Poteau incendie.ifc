Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-11-28T16:01:36
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Object; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy (4)
In: Default Building Storey
Description: Description of Object
Name
 | CompositionType - IfcElementCompositionEnum: complex
Reseaux Secs Telecom-video
2 x Object

# IfcFlowFitting (122)
In: Default Building Storey
Description: Description of Object
Name
TE DN100 dn100 à brides orientables | IFC 4 - SchemaType: http://www.buildingsmart-tech.org/ifcXML/IFC4/final:IfcFlowFitting
Tuyau FD DN100
Bride Traudée Ronde DN100 3/4''
107 x 
Cône DN100 dn80 à brides orientables
Robinet vanne DN80-Euro23
Coude 45° DN80 à brides orientables
Raccord Esse de réglage DN80 à brides orientables | TempShadowInfo - City: Boulder (CO); Country: USA; Latitude: 40.017; Longitude: 40.017-105.283; NorthAngle: 40.017-105.2830; TZOffset: 40.017-105.2830-7
Coude à patin 90° DN80 à brides orientables PN10
Bride Traudée Ronde DN80 3/4''
1/2 Bride orientable
2 x Raccord MAJOR pour FONTE DN100
2 x Raccord fonte pour PVC MAJOR DN80 PVC90
Poteau Incendie DN80 | IFC 4 - SchemaType: http://www.buildingsmart-tech.org/ifcXML/IFC4/final:IfcFlowFitting

# IfcFooting (3)
In: Default Building Storey
Description: Description of Object
PredefinedType - IfcFootingTypeEnum: footing_beam
Name

EP2-Massif-béton
EP2-Massif-Bloc béton 40x40x20

# IfcMember (2)
In: Default Building Storey
Description: Description of Object
Name
 | IFC 4 - SchemaType: http://www.buildingsmart-tech.org/ifcXML/IFC4/final:IfcMember
