Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Any]
File name: EP1-Etude 2-5 Regards 34113 à 34114.ifc
Time: 2024-10-25T14:35:55
Author: Frederic
Organization: Trimble
Written by: TrimBimToIFC ver 1.0
Made in: TrimBimToIFC ver 1.0
Authorization: IFC4 model

# IfcBuildingElementProxy: culvert (2)
PredefinedType: ELEMENT
Name
Tuyaux BA Ø600-tronçon 34113-34102-pente 2.57% -Réseaux Existant | SU_InstanceSet - Owner: rf
Tuyaux BA Ø600-tronçon 34119-34113-pente 1.66% -Réseaux Existant
