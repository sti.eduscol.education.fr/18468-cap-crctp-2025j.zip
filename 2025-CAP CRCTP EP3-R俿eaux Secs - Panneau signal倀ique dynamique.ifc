Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-11-28T18:25:18
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy, Object
In: Default Building Storey
Description: Description of Object

# IfcFlowFitting (4)
In: Default Building Storey
Description: Description of Object
Name
EP3-Réseaux Secs - Gaine TPC Ø 40 Blanc
Réseaux existant Video Télécom - Chambre de tirage L1T
Réseaux existant Video Télécom - Gaine TPC Ø63 Vert
Réseaux existant Video Télécom - Tampon de la CT

# IfcFooting (11)
In: Default Building Storey
Description: Description of Object
PredefinedType - IfcFootingTypeEnum: footing_beam
Name
Terrassement - Plateforme
EP3 - GO - Béton de remplissage
2 x EP3 - GO - Elément préfabriqué 40x40x20ht
EP3 - Terrassement - lit de pose de la gaine
EP3 - Go - Enrobage béton de la gaine
EP3 - Terrassement - Couche de sable 0/6 sur gaine
EP3 - Terrassement - Remblai grave 0/20
EP3-Go - Platine de scellement 150x150x5
EP3 - Terrassement - Remblai GNT 0/14 | PredefinedType - sets with these values: 2
Terrassement - Remblai du reseau existant

# IfcMember (16)
In: Default Building Storey
Description: Description of Object
Name
EP3 - Implantation - cordeau axe F
EP3 - Implantation - Piquet acier F2
EP3 - Implantation - Piquet acier F1
EP3 - Implantation - Piquet acier E2
EP3 - Implantation - cordeau axe E
EP3 - Implantation - piquet acier E1
Sécurité - Grillage avertisseur vert
EP3 - Sécurité - Grillage avertisseur BLANC
EP3-Panneau clignotant dynamique
EP3 - Marquage du réseau ERD
Implantation-Piquet A1
Implantation-Piquet B2
Implantation-Cordeau A1-A2
Implantation-Cordeau B1-B2
Implantation-Piquet B1
Implantation-Piquet A2
