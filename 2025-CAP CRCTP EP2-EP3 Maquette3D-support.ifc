Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-11-29T07:43:59
Made in: SketchUp Pro 2015

# IfcProject, Default Project
Description: Description of Default Project

# IfcSite, Default Site
Description: Description of Default Site; RefLatitude: 24, 28, 0; RefLongitude: 54, 25, 0; RefElevation: 10 mm

# IfcBuilding, Default Building
Description: Description of Default Building

# IfcBuildingStorey, Default Building Storey
In: Default Building
Description: Description of Default Building Storey; Elevation: 0 mm

# IfcBuildingElementProxy, Object
In: Default Building Storey
Description: Description of Object

# IfcFlowFitting (3)
In: Default Building Storey
Description: Description of Object
Name
Réseaux existant Video Télécom - Chambre de tirage L1T
Réseaux existant Video Télécom - Gaine TPC Ø63 Vert
Réseaux existant Video Télécom - Tampon de la CT

# IfcFooting (2)
In: Default Building Storey
Description: Description of Object
PredefinedType - IfcFootingTypeEnum: footing_beam
Name
Terrassement - Plateforme
Terrassement - Remblai du reseau existant

# IfcMember (7)
In: Default Building Storey
Description: Description of Object
Name
Sécurité - Grillage avertisseur vert
Implantation-Piquet A1
Implantation-Piquet B2
Implantation-Cordeau A1-A2
Implantation-Cordeau B1-B2
Implantation-Piquet B1
Implantation-Piquet A2
